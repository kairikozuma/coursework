# Keil uVision project 4180_lab2_part4_ex.uvprojx, settings and files
target 4180_lab2_part4_ex (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: 4180_lab2_part4_ex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DMBED_BUILD_TIMESTAMP=1486841553.34 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; LSM9DS1_Library_cal; LSM9DS1_Library_cal/PinDetect; 4DGL-uLCD-SE; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h main.cpp
  group 4DGL-uLCD-SE
    4DGL-uLCD-SE/: uLCD_4DGL.h uLCD_4DGL_main.cpp uLCD_4DGL_Media.cpp uLCD_4DGL_Text.cpp uLCD_4DGL_Graphics.cpp
  group TARGET_LPC1768
    mbed/TARGET_LPC1768/: LPC17xx.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h system_LPC17xx.h
  group LSM9DS1_Library_cal
    LSM9DS1_Library_cal/: LSM9DS1.h LSM9DS1_Registers.h LSM9DS1_Types.h LSM9DS1.cpp
  group TARGET_LPC176X
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: PeripheralNames.h PortNames.h gpio_object.h objects.h
  group PinDetect
    LSM9DS1_Library_cal/PinDetect/: PinDetect.h example.h ChangeLog.h
  group TARGET_MBED_LPC1768
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: PinNames.h device.h reserved_pins.h
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o mbed.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
