# Keil uVision project 4180_lab2_usb.uvprojx, settings and files
target 4180_lab2_usb (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: 4180_lab2_usb
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_PORTOUT=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE -DDEVICE_SLEEP=1 -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DMBED_BUILD_TIMESTAMP=1486841590.21 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; USBHostLite; FATFileSystem; FATFileSystem/LPC1768; mbed/.; mbed/LPC1768;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/LPC1768/LPC1768.sct
  group 
    ./: mbed_config.h MSCFileSystem.h MSCFileSystem.cpp main.cpp
  group LPC1768
    mbed/LPC1768/: LPC17xx.h core_cm3.h system_LPC17xx.h cmsis_nvic.o core_cm3.o stackheap.o startup_LPC17xx.o system_LPC17xx.o capi.ar mbed.ar
    FATFileSystem/LPC1768/: FATFileSystem.ar
  group USBHostLite
    USBHostLite/: usbhost_cpu.h usbhost_err.h usbhost_inc.h usbhost_lpc17xx.h usbhost_ms.h usbhost_lpc17xx.c usbhost_ms.c
  group FATFileSystem
    FATFileSystem/: FATDirHandle.h FATFileHandle.h FATFileSystem.h diskio.h ff.h integer.h
  group mbed
    mbed/: AnalogIn.h AnalogOut.h Base.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileHandle.h FileLike.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h PeripheralNames.h PinNames.h PortIn.h PortInOut.h PortNames.h PortOut.h PwmOut.h SPI.h SPIHalfDuplex.h SPISlave.h Serial.h SerialHalfDuplex.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h can_helper.h cmsis.h cmsis_nvic.h error.h mbed.h platform.h rpc.h rtc_time.h wait_api.h
