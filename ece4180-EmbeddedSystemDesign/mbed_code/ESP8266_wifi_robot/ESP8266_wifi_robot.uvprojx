# Keil uVision project ESP8266_wifi_robot.uvprojx, settings and files
target ESP8266_wifi_robot (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: ESP8266_wifi_robot
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DMBED_BUILD_TIMESTAMP=1486841696.74 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; Servo; mbed-rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM; mbed-rtos/rtos; Motordriver; mbed-dev; mbed-dev/hal; mbed-dev/hal/hal; mbed-dev/hal/storage_abstraction; mbed-dev/platform; mbed-dev/drivers; mbed-dev/targets; mbed-dev/targets/TARGET_NXP; mbed-dev/targets/TARGET_NXP/TARGET_LPC176X; mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/device; mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD; mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed-dev/cmsis;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h ESP8266.h main.cpp ESP8266.cpp
  group Motordriver
    Motordriver/: motordriver.h motordriver.cpp
  group hal
    mbed-dev/hal/: pwmout_api.h sleep_api.h serial_api.h gpio_api.h i2c_api.h can_api.h analogout_api.h dma_api.h lp_ticker_api.h pinmap.h ticker_api.h ethernet_api.h port_api.h analogin_api.h buffer.h rtc_api.h gpio_irq_api.h spi_api.h trng_api.h us_ticker_api.h can_helper.h mbed_ticker_api.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_us_ticker_api.c mbed_gpio.c
    mbed-dev/hal/hal/: emac_api.h
  group Servo
    Servo/: Servo.h Servo.cpp
  group platform
    mbed-dev/platform/: PlatformMutex.h semihost_api.h mbed_debug.h Transaction.h CallChain.h Callback.h mbed_error.h FunctionPointer.h toolchain.h platform.h CThunk.h CircularBuffer.h mbed_assert.h mbed_stats.h critical.h mbed_mem_trace.h mbed_interface.h SingletonPtr.h rtc_time.h wait_api.h mbed_semihost_api.c mbed_interface.c mbed_critical.c mbed_error.c mbed_wait_api_no_rtos.c mbed_mem_trace.c mbed_assert.c mbed_board.c mbed_wait_api_rtos.cpp retarget.cpp CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp
  group TARGET_CORTEX_M
    mbed-rtos/rtx/TARGET_CORTEX_M/: rt_Semaphore.h rt_HAL_CM.h RTX_Config.h RTX_CM_lib.h rt_Task.h rt_TypeDef.h rt_System.h rt_Mailbox.h rt_Event.h cmsis_os.h rt_Memory.h rt_Timer.h rt_Time.h rt_OsEventObserver.h rt_List.h rt_Mutex.h rt_MemBox.h rt_Robin.h rt_OsEventObserver.c rt_Task.c rt_System.c rt_List.c rt_Time.c rt_Semaphore.c rt_Mailbox.c rt_CMSIS.c HAL_CM.c rt_Timer.c rt_Robin.c rt_MemBox.c RTX_Conf_CM.c rt_Memory.c rt_Event.c rt_Mutex.c
  group rtos
    mbed-rtos/rtos/: MemoryPool.h Queue.h rtos_idle.h Mail.h RtosTimer.h Mutex.h rtos.h Thread.h Semaphore.h rtos_idle.c Thread.cpp RtosTimer.cpp Semaphore.cpp Mutex.cpp
  group TARGET_LPC176X
    mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/: gpio_object.h PortNames.h objects.h PeripheralNames.h port_api.c spi_api.c analogout_api.c analogin_api.c gpio_api.c rtc_api.c gpio_irq_api.c serial_api.c i2c_api.c pwmout_api.c ethernet_api.c sleep.c pinmap.c us_ticker.c can_api.c
  group TARGET_NXP
    mbed-dev/targets/TARGET_NXP/: mbed_rtx.h
  group TARGET_MBED_LPC1768
    mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h reserved_pins.h PinNames.h
  group mbed-dev
    mbed-dev/: mbed.h
  group storage_abstraction
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group device
    mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/device/: LPC17xx.h cmsis.h cmsis_nvic.h system_LPC17xx.h cmsis_nvic.c system_LPC17xx.c
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM3.c
  group TOOLCHAIN_ARM_STD
    mbed-dev/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/: startup_LPC17xx.S sys.cpp
  group cmsis
    mbed-dev/cmsis/: core_cm3.h core_cm4_simd.h core_cm4.h core_ca9.h core_cmSimd.h core_sc300.h core_caInstr.h core_caFunc.h core_cmFunc.h core_ca_mmu.h core_cmSecureAccess.h core_cmInstr.h core_sc000.h core_cm7.h arm_math.h arm_const_structs.h arm_common_tables.h core_cm0plus.h core_cm0.h
  group drivers
    mbed-dev/drivers/: InterruptIn.h Ticker.h InterruptManager.h I2CSlave.h FileBase.h PortIn.h LowPowerTicker.h Timeout.h LowPowerTimeout.h DigitalInOut.h Timer.h SPI.h BusInOut.h SerialBase.h TimerEvent.h SPISlave.h BusIn.h RawSerial.h FilePath.h DigitalIn.h AnalogIn.h AnalogOut.h DirHandle.h FileSystemLike.h PwmOut.h FileHandle.h CAN.h Serial.h I2C.h LowPowerTimer.h FileLike.h Stream.h DigitalOut.h PortOut.h PortInOut.h LocalFileSystem.h Ethernet.h BusOut.h RawSerial.cpp Ticker.cpp FilePath.cpp I2C.cpp FileBase.cpp Serial.cpp Stream.cpp FileSystemLike.cpp InterruptManager.cpp SerialBase.cpp BusInOut.cpp SPISlave.cpp I2CSlave.cpp Timer.cpp SPI.cpp AnalogIn.cpp Timeout.cpp Ethernet.cpp TimerEvent.cpp CAN.cpp BusOut.cpp FileLike.cpp BusIn.cpp InterruptIn.cpp LocalFileSystem.cpp
