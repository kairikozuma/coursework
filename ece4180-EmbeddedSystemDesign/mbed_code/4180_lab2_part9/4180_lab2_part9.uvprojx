# Keil uVision project 4180_lab2_part9.uvprojx, settings and files
target 4180_lab2_part9 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: 4180_lab2_part9
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti --split_sections -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -Ospace -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_BUILD_TIMESTAMP=1486841582.69 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; SDFileSystem; SDFileSystem/FATFileSystem; SDFileSystem/FATFileSystem/ChaN; mbed/.; mbed/LPC1768; mbed/LPC1768/ARM;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/LPC1768/ARM/LPC1768.sct
  group 
    ./: mbed_config.h main.cpp
  group FATFileSystem
    SDFileSystem/FATFileSystem/: FATDirHandle.h FATFileHandle.h FATFileSystem.h FATFileSystem.cpp FATFileHandle.cpp FATDirHandle.cpp
  group ChaN
    SDFileSystem/FATFileSystem/ChaN/: diskio.h integer.h ffconf.h ff.h diskio.cpp ccsbcs.cpp ff.cpp
  group LPC1768
    mbed/LPC1768/: LPC17xx.h PeripheralNames.h PinNames.h PortNames.h cmsis.h cmsis_nvic.h core_cm3.h core_cmFunc.h core_cmInstr.h device.h gpio_object.h objects.h system_LPC17xx.h
  group SDFileSystem
    SDFileSystem/: SDFileSystem.h SDFileSystem.cpp
  group ARM
    mbed/LPC1768/ARM/: cmsis_nvic.o core_cm3.o startup_LPC17xx.o sys.o system_LPC17xx.o capi.ar cpp.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileHandle.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h PortIn.h PortInOut.h PortOut.h PwmOut.h SPI.h SPISlave.h Serial.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h analogin_api.h analogout_api.h can_api.h can_helper.h error.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h toolchain.h us_ticker_api.h wait_api.h
