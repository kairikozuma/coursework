# Keil uVision project ESP8266_HTTP_HelloWorld.uvprojx, settings and files
target ESP8266_HTTP_HelloWorld (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: ESP8266_HTTP_HelloWorld
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DMBED_BUILD_TIMESTAMP=1486841679.6 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; ESP8266Interface; ESP8266Interface/ESP8266; ESP8266Interface/Helper; ESP8266Interface/Socket; HTTPClient-SSL; HTTPClient-SSL/data; HTTPClient-SSL/CyaSSL; HTTPClient-SSL/CyaSSL/ctaocrypt; HTTPClient-SSL/CyaSSL/ctaocrypt/src; HTTPClient-SSL/CyaSSL/cyassl; HTTPClient-SSL/CyaSSL/cyassl/ctaocrypt; HTTPClient-SSL/CyaSSL/cyassl/openssl; HTTPClient-SSL/CyaSSL/src; WebSocketClient; mbed-rtos; mbed-rtos/rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h main.cpp
  group src
    HTTPClient-SSL/CyaSSL/ctaocrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c coding.c compress.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c fips.c fips_test.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c port.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c
    HTTPClient-SSL/CyaSSL/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM3.c
  group Socket
    ESP8266Interface/Socket/: Endpoint.h Socket.h TCPSocketConnection.h TCPSocketServer.h UDPSocket.h Endpoint.cpp Socket.cpp TCPSocketConnection.cpp TCPSocketServer.cpp UDPSocket.cpp
  group Helper
    ESP8266Interface/Helper/: def.h
  group WebSocketClient
    WebSocketClient/: Websocket.h Websocket.cpp
  group openssl
    HTTPClient-SSL/CyaSSL/cyassl/openssl/: asn1.h bio.h bn.h conf.h crypto.h des.h dh.h dsa.h ec.h ecdsa.h engine.h err.h evp.h hmac.h lhash.h md4.h md5.h ocsp.h opensslconf.h opensslv.h ossl_typ.h pem.h pkcs12.h rand.h ripemd.h rsa.h sha.h ssl.h stack.h ui.h x509.h x509v3.h
  group TARGET_CORTEX_M
    mbed-rtos/rtx/TARGET_CORTEX_M/: RTX_CM_lib.h RTX_Conf.h cmsis_os.h os_tcb.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
  group rtos
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group TARGET_LPC1768
    mbed/TARGET_LPC1768/: LPC17xx.h cmsis.h cmsis_nvic.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h system_LPC17xx.h
  group ESP8266Interface
    ESP8266Interface/: ESP8266Interface.h ESP8266Interface.cpp
  group TARGET_LPC176X
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: PeripheralNames.h PortNames.h gpio_object.h objects.h
  group cyassl
    HTTPClient-SSL/CyaSSL/cyassl/: callbacks.h certs_test.h crl.h error-ssl.h internal.h ocsp.h options.h sniffer.h ssl.h test.h version.h
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CThunk.h CallChain.h CircularBuffer.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h Transaction.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h toolchain.h us_ticker_api.h wait_api.h
  group HTTPClient-SSL
    HTTPClient-SSL/: HTTPClient.h IHTTPData.h HTTPClient.cpp
  group TARGET_MBED_LPC1768
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: PinNames.h device.h reserved_pins.h
  group data
    HTTPClient-SSL/data/: HTTPFormEncoded.h HTTPJson.h HTTPMap.h HTTPText.h HTTPFormEncoded.cpp HTTPJson.cpp HTTPMap.cpp HTTPText.cpp
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o mbed.ar
  group ctaocrypt
    HTTPClient-SSL/CyaSSL/cyassl/ctaocrypt/: aes.h arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h coding.h compress.h des3.h dh.h dsa.h ecc.h error-crypt.h fips_test.h hc128.h hmac.h integer.h logging.h md2.h md4.h md5.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs7.h port.h pwdbased.h rabbit.h random.h ripemd.h rsa.h settings.h sha.h sha256.h sha512.h tfm.h types.h visibility.h
  group ESP8266
    ESP8266Interface/ESP8266/: CBuffer.h ESP8266.h ESP8266.cpp
