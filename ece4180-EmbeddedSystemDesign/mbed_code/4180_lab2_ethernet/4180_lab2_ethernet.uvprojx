# Keil uVision project 4180_lab2_ethernet.uvprojx, settings and files
target 4180_lab2_ethernet (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.pdsc
  output: 4180_lab2_ethernet
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DMBED_BUILD_TIMESTAMP=1486841524.37 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; EthernetInterface; EthernetInterface/Socket; EthernetInterface/lwip-eth; EthernetInterface/lwip-eth/arch; EthernetInterface/lwip-eth/arch/TARGET_NXP; EthernetInterface/lwip-sys; EthernetInterface/lwip-sys/arch; EthernetInterface/lwip; EthernetInterface/lwip/api; EthernetInterface/lwip/core; EthernetInterface/lwip/core/ipv4; EthernetInterface/lwip/core/snmp; EthernetInterface/lwip/include; EthernetInterface/lwip/include/ipv4; EthernetInterface/lwip/include/ipv4/lwip; EthernetInterface/lwip/include/lwip; EthernetInterface/lwip/include/netif; EthernetInterface/lwip/netif; EthernetInterface/lwip/netif/ppp; mbed-rtos; mbed-rtos/rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_M3; mbed-rtos/rtx/TARGET_M3/TOOLCHAIN_ARM; mbed/.; mbed/TARGET_LPC1768; mbed/TARGET_LPC1768/TARGET_NXP; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X; mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h main.cpp
  group core
    EthernetInterface/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group TOOLCHAIN_ARM
    mbed-rtos/rtx/TARGET_M3/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM3.c
  group lwip
    EthernetInterface/lwip/: lwipopts.h
    EthernetInterface/lwip/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
    EthernetInterface/lwip/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcp_impl.h tcpip.h timers.h udp.h
  group Socket
    EthernetInterface/Socket/: Endpoint.h Socket.h TCPSocketConnection.h TCPSocketServer.h UDPSocket.h Endpoint.cpp Socket.cpp TCPSocketConnection.cpp TCPSocketServer.cpp UDPSocket.cpp
  group EthernetInterface
    EthernetInterface/: EthernetInterface.h eth_arch.h EthernetInterface.cpp
  group snmp
    EthernetInterface/lwip/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group rtos
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group TARGET_LPC176X
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: PeripheralNames.h PortNames.h gpio_object.h objects.h
  group TARGET_NXP
    EthernetInterface/lwip-eth/arch/TARGET_NXP/: lpc17xx_emac.h lpc_emac_config.h lpc_phy.h lwipopts_conf.h lpc17_emac.c lpc_phy_dp83848.c
  group TARGET_LPC1768
    mbed/TARGET_LPC1768/: LPC17xx.h cmsis.h cmsis_nvic.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h system_LPC17xx.h
  group api
    EthernetInterface/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group ipv4
    EthernetInterface/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group ppp
    EthernetInterface/lwip/netif/ppp/: auth.h chap.h chpms.h fsm.h ipcp.h lcp.h magic.h md5.h pap.h ppp.h pppdebug.h randm.h vj.h auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group rtx
    mbed-rtos/rtx/: RTX_CM_lib.h RTX_Conf.h cmsis_os.h os_tcb.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Mutex.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c
  group TARGET_MBED_LPC1768
    mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: PinNames.h device.h reserved_pins.h
  group arch
    EthernetInterface/lwip-sys/arch/: cc.h perf.h sys_arch.h checksum.c memcpy.c sys_arch.c
  group TOOLCHAIN_ARM_STD
    mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: board.o cmsis_nvic.o retarget.o startup_LPC17xx.o sys.o system_LPC17xx.o mbed.ar
  group mbed
    mbed/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h CallChain.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h analogin_api.h analogout_api.h can_api.h can_helper.h error.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h mbed.h mbed_debug.h mbed_interface.h pinmap.h platform.h port_api.h pwmout_api.h rtc_api.h rtc_time.h semihost_api.h serial_api.h sleep_api.h spi_api.h toolchain.h us_ticker_api.h wait_api.h
  group netif
    EthernetInterface/lwip/include/netif/: etharp.h ppp_oe.h slipif.h
    EthernetInterface/lwip/netif/: etharp.c ethernetif.c slipif.c
